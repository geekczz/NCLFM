# Keil uVision project myproject.uvprojx, settings and files
target MyProject (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: WeighingFillMachine +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030 USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\LIB\inc;..\DRIVER;..\USER
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../CMSIS/: system_stm32f0xx.c arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cmFunc.h core_cmInstr.h stm32f0xx.h system_stm32f0xx.h startup_stm32f030.s
  group DRIVER
    ../DRIVER/: stm32f0xx_it.c stm32f0xx_conf.h stm32f0xx_it.h LX12864B_Driver.c LX12864B_Driver.h ElectronicScaleDriver.c ElectronicScaleDriver.h
  group LIB
    ../LIB/src/: stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_gpio.c stm32f0xx_dma.c stm32f0xx_misc.c stm32f0xx_tim.c stm32f0xx_flash.c
  group USER
    ../USER/: main.c BSP.c
